# Keil uVision project BasicSTC12_RX51_Tiny.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: BasicSTC12_RX51_Tiny +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Startup
    ./: STARTUP.A51
  group Include
    ./: ads1115.h at24c02.h binary.h delay.h gpio.h i2csoft.h intdef.h lcd1602.h stc12c5a60s2.h hardware_serial2.h
  group Source
    ./: ads1115.c at24c02.c delay.c gpio.c i2csoft.c lcd1602.c main.c hardware_serial2.c
